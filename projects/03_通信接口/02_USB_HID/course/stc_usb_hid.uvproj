# Keil uVision project stc_usb_hid.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: stc_usb_hid +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./src/: main.c usb.c usb_desc.c usb_req_class.c usb_req_std.c usb_req_vendor.c util.c
    ./: 功能说明.txt Delay.c GPIO.c MatrixKey.c NVIC.c UART.c UART_Isr.c
